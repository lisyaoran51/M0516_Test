# Keil uVision project I2C_Slave.uvproj, settings and files
target I2C_Slave (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: (Generic) M051 Series Nuvoton
  cpu: CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: I2C_Slave
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG_ENABLE_SEMIHOST=1
  c include: ..\Library\Device\Nuvoton\M051Series\Include;..\Library\CMSIS\Include;..\Library\StdDriver\inc;..\Library\M051-LB_004\inc;..\
  library: MicroLIB
  link misc: --map --first='startup_M051Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../Library/Device/Nuvoton/M051Series/Source/: system_M051Series.c
    ../Library/Device/Nuvoton/M051Series/Source/ARM/: startup_M051Series.s
  group User
    ../: I2cInterface.c I2cInterface.h CircularLinkedList.c CircularLinkedList.h main.c
  group Library
    ../Library/StdDriver/src/: retarget.c clk.c i2c.c sys.c uart.c
